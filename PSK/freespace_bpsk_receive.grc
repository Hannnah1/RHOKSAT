options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: G
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.100'
    stop: '10'
    value: '1'
  states: {}
- name: bpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[-1, 1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '315000000'
  states: {}
- name: fc_Mhz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '300'
    step: '10'
    stop: '330'
    value: '315'
  states: {}
- name: fe
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1000'
    step: '0.100'
    stop: '1000'
    value: '0'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sym_delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '16'
    value: '0'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: theta10
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option1: '-90'
    option2: '90'
    option3: '180'
    type: int
    value: '0'
  states: {}
- name: theta2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fe
    offset: '0'
    phase: '0'
    samp_rate: fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sym_delay
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts1/1
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: G * np.exp(1j*np.pi*(theta1+theta2)/180.0)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_const
    fmax: '100'
    fmin: '-100'
    loop_bw: '0.0625'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.06'
    max_dev: '1.5'
    osps: '1'
    sps: samp_per_symbol
    taps: firdes.root_raised_cosine(32, 32, 1.0/float(samp_per_symbol), 0.35, 45*32)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"PAM transmitter"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Recvr Sampled"'
    size: '64'
    srate: '32000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"PAM Recvr"'
    nconnections: '3'
    size: '64'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fc
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '256000'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_delay_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_delay_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', qtgui_time_sink_x_1_0, '0']
- [digital_constellation_receiver_cb_0, '2', qtgui_time_sink_x_1_0, '1']
- [digital_constellation_receiver_cb_0, '3', qtgui_time_sink_x_1_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_delay_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
