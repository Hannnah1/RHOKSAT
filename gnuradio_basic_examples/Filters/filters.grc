options:
  parameters:
    author: hannah
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: filters
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: sample_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '24000'
    low_cutoff_freq: '300'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '100'
    low_cutoff_freq: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hannah/Downloads/yellow_submarine.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_reject_filter_0, '0', blocks_null_sink_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_reject_filter_0, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [high_pass_filter_0, '0', blocks_null_sink_1, '0']
- [low_pass_filter_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
