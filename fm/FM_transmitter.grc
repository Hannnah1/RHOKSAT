options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
    title: FM transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 24e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gstation/Desktop/Thunderstruck.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: 100e3
    digital_bandw_ch1: 100e3
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: '903400000'
    samp_rate: 2e6
    serial: 0009081C05C42112
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    style1: '4'
    type: complex
    update_time: '1.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '24'
    taps: ''
    type: ccf
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
